# Keil uVision project f746_os.uvprojx, settings and files
target f746_os (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F746NGHx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.9.0
  cpu: IRAM(0x20000000-0x2004FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(12000000) FPU3(SFPU) CPUTYPE("Cortex-M7") ELITTLE
  output: f746_os +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F746xx,USE_HAL_DRIVER,STM32F746xx
  c include: ../Core/Inc;  ../FATFS/Target;  ../FATFS/App;  ../Drivers/STM32F7xx_HAL_Driver/Inc;  ../Drivers/STM32F7xx_HAL_Driver/Inc/Legacy;  ../Middlewares/Third_Party/FatFs/src;  ../Middlewares/Third_Party/FreeRTOS/Source/include;  ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;  ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM7/r0p1;  ../Drivers/CMSIS/Device/ST/STM32F7xx/Include;  ../Drivers/CMSIS/Include;  ..\test
  asm include: ..\Core\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x50000
  group Application/MDK-ARM
    ./: startup_stm32f746xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c dma.c freertos.c sdmmc.c stm32f7xx_it.c stm32f7xx_hal_msp.c
  group Application/User/FATFS/Target
    ../FATFS/Target/: bsp_driver_sd.c sd_diskio.c
  group Application/User/FATFS/App
    ../FATFS/App/: fatfs.c
  group Drivers/STM32F7xx_HAL_Driver
    ../Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal_cortex.c stm32f7xx_ll_sdmmc.c stm32f7xx_hal_sd.c stm32f7xx_hal_tim.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_flash.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_dma.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal.c stm32f7xx_hal_i2c.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_exti.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f7xx.c
  group Middlewares/FatFs
    ../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
    ../Middlewares/Third_Party/FatFs/src/option/: syscall.c ccsbcs.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM7/r0p1/: port.c
  group test
    ../test/: test.c
software components: CMSIS:CORE 4.3.0
